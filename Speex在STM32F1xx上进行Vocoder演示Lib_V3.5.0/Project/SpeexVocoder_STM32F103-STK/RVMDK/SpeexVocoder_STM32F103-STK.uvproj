# Keil uVision project SpeexVocoder_STM32F103-STK.uvproj, settings and files
target SpeexVocoder_STM32F103-STK (ARM-ADS)
  device: STM32F107RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: SpeexVocoder_STM32F103-STK +hex
  c flags: Optim=3 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD,HAVE_CONFIG_H
  c include: ..\inc;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Libraries\STM32F10x_Speex_Lib\include;..\..\..\Libraries\STM32F10x_Speex_Lib\libspeex;..\..\..\Libraries\STM32F10x_Speex_Lib\STM32;..\..\..\Libraries\STM32F10x_Speex_Lib\STM32\include;..\..\..\Libraries\STM32F10x_Speex_Lib\STM32\libspeex;..\..\..\Libraries\STM32F10x_Speex_Lib\STM32\libspeex\arm;..\..\..\Libraries\CMSIS\Core\CM3;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../src/: lcd.c main.c stm32f10x_it.c vocoder.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_sdio.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_iwdg.c stm32f10x_i2c.c stm32f10x_fsmc.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_dbgmcu.c stm32f10x_dac.c stm32f10x_crc.c stm32f10x_cec.c stm32f10x_can.c stm32f10x_bkp.c
  group RVMDK
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
  group libspeex
    ../../../Libraries/STM32F10x_Speex_Lib/libspeex/: window.c bits.c exc_10_32_table.c gain_table_lbr.c lpc.c lsp.c speex.c speex_callbacks.c speex_header.c buffer.c high_lsp_tables.c lsp_tables_nb.c
    ../../../Libraries/STM32F10x_Speex_Lib/STM32/libspeex/: modes.c nb_celp.c quant_lsp.c vq.c cb_search.c filters.c ltp.c
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group DOC
    ../: readme.txt
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
